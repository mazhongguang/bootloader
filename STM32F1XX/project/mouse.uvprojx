# Keil uVision project mouse.uvprojx, settings and files
target bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  .\Objects\bootloader.bin .\Objects\bootloader.axf
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_HAL_DRIVER,USE_FULL_LL_DRIVER
  c include: ..\app;..\core;..\hallib\Inc;..\hallib\Inc\Legacy;..\core\arm;..\SYSTEM\usart;..\SYSTEM\sys;..\SYSTEM\delay;..\hardware\button;..\hardware\led;..\hardware\iap;..\hardware\stmflash
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x37000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ../app/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group core
    ../core/: system_stm32f1xx.c
    ../core/arm/: startup_stm32f103xb.s
  group hallib
    ../hallib/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_usart.c stm32f1xx_ll_rcc.c
  group system
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group hardware
    ../hardware/button/: button.c
    ../hardware/led/: led.c
    ../hardware/iap/: iap.c
    ../hardware/stmflash/: stmflash.c
