# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F301K8Ux STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  .\Objects\bootloader.bin .\Objects\bootloader.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F301x8,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,WIN32
  c include: ..\app;..\core;..\core\arm;..\hallib\Inc\Legacy;..\hallib\Inc;..\hardware\button;..\hardware\iap;..\hardware\led;..\hardware\stmflash;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../app/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c
  group core
    ../core/: system_stm32f3xx.c
    ../core/arm/: startup_stm32f301x8.s
  group hallib
    ../hallib/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_pwr.c stm32f3xx_hal_rcc.c stm32f3xx_hal_uart.c stm32f3xx_ll_usart.c stm32f3xx_hal_dma.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_rcc_ex.c stm32f3xx_ll_rcc.c
  group hardware
    ../hardware/button/: button.c
    ../hardware/iap/: iap.c
    ../hardware/led/: led.c
    ../hardware/stmflash/: stmflash.c
  group system
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
